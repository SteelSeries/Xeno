# IAR project Xeno_2.ewp, settings and files
configuration Xeno_2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F723IE ST STM32F723IE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F723xx; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../Core/Inc; ../../../../../common/STM32/Composite; ../../../../../common/STM32/Drivers/STM32F7xx_HAL_Driver/Inc; ../../../../../common/STM32/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../../../../../common/STM32/Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../../../../../common/STM32/Drivers/CMSIS/Include; ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/HID_KEYBOARD/Inc; ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/HID_CUSTOM/Inc; ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/App; ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Core/Inc; ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Target; ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/COMPOSITE/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Xeno_2.bin
  ILINK.IlinkOutputFile: Xeno_2.out
  ILINK.IlinkIcfFile: stm32f723xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f723xx.s
  group Application/User/Core
    ../Core/Src/: Commands.c Commands_spi.c gpio.c main.c power_manager.c spi.c spi_protocol.c stm32f723e_discovery.c stm32f7xx_hal_msp.c stm32f7xx_it.c uart.c usb_otg.c version.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../common/STM32/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_usb.c
  group Middlewares/Composite/USB/COMPOSITE/COMPOSITE
    ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/COMPOSITE/Src/: usbd_composite.c
  group Middlewares/Composite/USB/COMPOSITE/Core
    ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/App/: usb_device.c usbd_desc.c
    ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Target/: usbd_conf.c
    ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/Composite/USB/COMPOSITE/HID_CUSTOM
    ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/HID_CUSTOM/Src/: usbd_hid_custom.c
    ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/App/: usbd_hid_custom_if.c
  group Middlewares/Composite/USB/COMPOSITE/HID_KEYBOARD
    ../../../../../common/STM32/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/HID_KEYBOARD/Src/: usbd_hid_keyboard.c
