# IAR project Xeno_96.ewp, settings and files
configuration Xeno_96 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F402RCT7_v2 ArteryTek AT32F402RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F402RCT7; USE_STDPERIPH_DRIVER; AT_START_F402_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\common\Artery\libraries\drivers\inc; ..\..\..\..\..\..\common\Artery\libraries\cmsis\cm4\core_support; ..\..\..\..\..\..\common\Artery\libraries\cmsis\cm4\device_support; ..\inc; ..\..\at32f402_405_board
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Xeno_96.bin
  ILINK.IlinkOutputFile: Xeno_96.out
  ILINK.IlinkIcfFile: Xeno_96.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../at32f402_405_board/: at32f402_405_board.c
  group cmsis
    ../../../../../../common/Artery/libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f402_405.s
    ../../../../../../common/Artery/libraries/cmsis/cm4/device_support/: system_at32f402_405.c
  group firmware
    ../../../../../../common/Artery/libraries/drivers/src/: at32f402_405_acc.c at32f402_405_adc.c at32f402_405_can.c at32f402_405_crc.c at32f402_405_crm.c at32f402_405_debug.c at32f402_405_dma.c at32f402_405_ertc.c at32f402_405_exint.c at32f402_405_flash.c at32f402_405_gpio.c at32f402_405_i2c.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_qspi.c at32f402_405_scfg.c at32f402_405_spi.c at32f402_405_tmr.c at32f402_405_usart.c at32f402_405_usb.c at32f402_405_wdt.c at32f402_405_wwdt.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f402_405_clock.c at32f402_405_int.c Commands.c main.c parser.c power_control.c spi.c
